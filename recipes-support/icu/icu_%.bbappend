PACKAGECONFIG:pn-icu-native += " make-icudata"
